Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Dolcevita - Bar stool - ver4.ifc
Time: 2024-01-11T14:55:22
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (31)
Name
 | Dolcevita - Bar stoo modell_0 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_1 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_2 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_3 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_4 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_5 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_6 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_7 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_8 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_9 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_10 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_11 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_12 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_13 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_14 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_15 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_16 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_17 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_18 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_19 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_20 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_21 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_22 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_23 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_24 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_25 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_26 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_27 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_28 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_29 - ObjectType: SketchupGroup
 | Dolcevita - Bar stoo modell_30 - ObjectType: SketchupGroup
